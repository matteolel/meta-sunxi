SRC_URI += "file://0001-fix-struct-_Window-backStorage-related-compile-failu.patch;subdir=git"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

